## config/board/shields/vbone_pico_shield/Kconfig.shield
```kconfig
config SHIELD_VBONE_PICO_SHIELD
    def_bool $(shields_list_contains,vbone_pico_shield)
```
